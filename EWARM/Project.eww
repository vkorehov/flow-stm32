<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\flow4.ewp</path>
  </project>
  <batchBuild />
</workspace>
